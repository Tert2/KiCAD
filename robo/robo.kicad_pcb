# Repository Tert2/KiCAD

File README.md:

# Overview
- This is the KiCAD Projects Repository.
- I recommend not to use these KiCAD data.
- Some projects are unfinished or have issues in the circuit.
- I designed these circuits based on whether I can solder them, not on whether the average person can.

## KiCad design robo/robo.kicad_pcb

Parts:
C1, C2, C8, C9, C10, C11, C12: 0u1; C1608
C3, C4, C5, C6, C7: 100uF 16V; CP_Radial_D6.3mm_P2.50mm
D1: 3v6; SOT-323_SC-70
D2: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
D3, D4: D_Schottky; CUHS20F30H3F
IC1, IC2: RT9080N-08GJ5; SOT94P280X100-5N; Manufacturer_Part_Number RT9080N-08GJ5; Mouser Part Number 835-RT9080N-08GJ5
J1, J2, J3, J4: Conn_01x02_Pin; PinHeader_2x01_P2.54mm_Vertical
J5, J6, J7, J8, J9: Conn_01x02_Pin; JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal
J10: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4110
JP1, JP2: Jumper_2_Open; jp_op
R1, R2: 5k1; R1608
R3, R4, R5, R6: 10k; R1608
SW1, SW2: SW_MEC_5E; THAF01NCR
U1: ESP32-C3-WROOM-02

Connections:
+3.3V: C12.1, D2.1 (VDD), D3.1 (K), D4.1 (K), R3.1, R4.1, R5.1, R6.1, U1.1 (3V3)
+BATT: C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, IC1.1 (VIN), IC1.3 (EN), J5.1, J6.1, J7.1, J8.1, J9.1
-BATT: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, D1.3 (A), D2.3 (VSS), IC1.2 (GND), IC2.2 (GND), J5.2, J6.2, J7.2, J8.2, J9.2, J10.A1 (GND), J10.A12 (GND), J10.B1 (GND), J10.B12 (GND), J10.SH (SHIELD), R1.2, R2.2, SW1.1, SW1.2, SW2.1, SW2.2, U1.9 (GND), U1.19 (GND)
/BOOT: C2.1, R6.2, SW2.3 (K), SW2.4 (A), U1.8 (IO9)
/D+: D1.1 (K), J10.A6 (D+), J10.B6 (D+), JP1.2 (B), U1.14 (IO19)
/D-: D1.2 (K), J10.A7 (D-), J10.B7 (D-), JP2.2 (B), U1.13 (IO18)
/EN: C1.1, R3.2, SW1.3 (K), SW1.4 (A), U1.2 (EN)
/NEO: D2.4 (DIN), U1.7 (IO8)
/SCL: J1.1, J2.1, J3.1, J4.1, R5.2, U1.17 (IO1)
/SDA: J1.2, J2.2, J3.2, J4.2, R4.2, U1.18 (IO0)
unnamed: C10.1, D3.2 (A), IC1.5 (VOUT)
unnamed: C11.1, D4.2 (A), IC2.5 (VOUT)
unnamed: J10.A5 (CC1), R1.1
unnamed: J10.B5 (CC2), R2.1
unnamed: JP1.1 (A), U1.11 (IO20/RXD)
unnamed: JP2.1 (A), U1.12 (IO21/TXD)
VBUS: C9.1, IC2.1 (VIN), IC2.3 (EN), J10.A4 (VBUS), J10.A9 (VBUS), J10.B4 (VBUS), J10.B9 (VBUS)

Notes on the sheet:
motor A-D

Board: 2 copper layers, 55.0 x 45.0 mm, 42 parts (0 on the bottom side), 17 nets.

Other parts of the board:
REF1, REF2, REF3: MountingHole_2.2mm_M2

## KiCad design controller2/controller_改.kicad_pcb

Board: 2 copper layers, 69.0 x 48.0 mm, 34 parts (0 on the bottom side), 22 nets.

Parts:
C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13: 1u; C_0603_1608Metric
D1: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
D2, D3: LED_Small; LED_0603_1608Metric
IC1: RT9080N-08GJ5; SOT94P280X100-5N
IC2: JT8P-3.2T-B10K-1-16Y; JT8P32TB10K116Y
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4110
J2, J3, J4: Conn_01x02_Pin; BAT_PAD
R1, R2: 4.7k; R_0603_1608Metric
R3: 10k; R_0603_1608Metric
R4, R5: R_Small; R_0603_1608Metric
SW1, SW2: SW_MEC_5E; SW_SKRPABE010
SW3, SW4, SW5, SW6: SW_Push; SKRGAAD010
U1: ESP32-C3-WROOM-02
U2, U3: SOT-23-3

Connections:
+3V3: C5.2, C6.2, IC1.5 (VOUT), IC2.A1, IC2.B1, R3.1, R5.1, U1.1 (3V3)
+5V: C7.2, D1.1 (VDD), IC1.1 (VIN), IC1.3 (EN), U2.2 (V-), U3.2 (V-)
+BATT: J2.1, R4.1, U3.3 (V+)
/EN: C4.2, R3.2, SW2.1, SW2.2, U1.2 (EN)
/IO0: IC2.A2, U1.18 (IO0)
/IO1: IC2.B2, U1.17 (IO1)
/IO2: C8.2, SW3.1, U1.16 (IO2)
/IO3: C9.2, SW4.1, U1.15 (IO3)
/IO4: C12.2, J3.2, U1.3 (IO4)
/IO5: C13.2, J4.2, U1.4 (IO5)
/IO6: C11.2, SW6.1, U1.5 (IO6)
/IO7: C10.2, SW5.1, U1.7 (IO8)
/IO8: D1.4 (DIN), U1.6 (IO7)
/IO9: C3.2, SW1.1, SW1.2, U1.8 (IO9)
D+: J1.A6 (D+), J1.B6 (D+), U1.14 (IO19)
D-: J1.A7 (D-), J1.B7 (D-), U1.13 (IO18)
GND: C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, D1.3 (VSS), D2.1 (K), D3.1 (K), IC1.2 (GND), IC2.A3, IC2.B3, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.2, J3.1, J4.1, R1.2, R2.2, SW1.3 (K), SW1.4 (A), SW2.3 (K), SW2.4 (A), SW3.2, SW4.2, SW5.2, SW6.2, U1.9 (GND), U1.19 (GND), U2.1 (GND), U3.1 (GND)
unnamed: D2.2 (A), R4.2
unnamed: D3.2 (A), R5.2
unnamed: J1.A5 (CC1), R1.1
unnamed: J1.B5 (CC2), R2.1
VBUS: J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U2.3 (V+)

## KiCad design mtdrv/mtdrv.kicad_pcb

Board: 2 copper layers, 12.0 x 20.5 mm, 20 parts (2 on the bottom side), 13 nets.

Parts:
C1, C3, C4: 0u1; 1005
C2: 100u/16V; CP_EIA-7343-15_Kemet-W
C5: 10u; C1608
C6: 10u; C_0805_2012Metric
IC1: BD6222HFP-TR; BD6222HFPTR
IC2: RT9080N-08GJ5; SOT94P280X100-5N
J1: Conn_01x02_Pin; smd_1.27mm_01x02
J2: Conn_01x02_Pin; PinHeader_2x01_P2.54mm_Vertical
J3: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
R1, R2, R4: 10k; R1005
R3, R5: 4k7; R1005
R6: 6k2; R1005
U1: ATtiny402-SS; SOIC-8_3.9x4.9mm_P1.27mm
U2: TLV9001IDCK; SOT-353_SC-70-5
U3: SOT-363_SC-70-6

Connections:
+3V3: C1.2, C2.1, C4.1, IC2.5 (VOUT), R3.2, R4.1, R5.2, U1.1 (VCC), U2.5 (V+), U3.6 (V+)
/CCW: IC1.5 (RIN), R2.1, U1.2 (PA6)
/CW: IC1.3 (FIN), R1.1, U1.3 (PA7)
/OA: IC1.2 (OUT1), J2.2, U3.3 (-)
/OB: IC1.6 (OUT2), J2.1, U3.1 (+)
/SCL: J1.1, R5.1, U1.5 (PA2)
/SDA: J1.2, R3.1, U1.4 (PA1)
/UPDI: J3.1, U1.6 (~RESET/PA0)
/ref: U1.7 (PA3), U3.4
/vref: U2.3 (-), U2.4, U3.5 (ref)
GND: C1.1, C2.2, C3.2, C4.2, C5.2, C6.1, IC1.4 (GND_1), IC1.8 (GND_2), IC2.2 (GND), J3.2, R1.2, R2.2, R6.2, U1.8 (GND), U2.2 (V-), U3.2 (V-)
unnamed: C3.1, R4.2, R6.1, U2.1 (+)
VCC: C5.1, C6.2, IC1.1 (VREF), IC1.7 (VCC), IC2.1 (VIN), IC2.3 (EN), J3.3

## KiCad design NiHmod/NiHmod.kicad_pcb

Parts:
C1, C3, C4: 10u/16V; C1608; MPN GRM188R61C106KAAL
C2: 0.1u/50V; 1005; MPN GRM155R71H104KE
D1: CUHS20S30; CUHS20S30_US2H; MPN CUHS20S30
J1: Vin/Vout; Pad_SMD_1x03_P2.54mm_W2.0mm
J2: Battery 3S NiMH; Pad_SMD_1x02_P2.54mm_W2.0mm
J3: Thermistor; Pad_SMD_1x02_P2.54mm_W2.0mm
LED1: Red (CHG); D1005; MPN OSR50402C1C
Q1: SSM3J332R; SOT-23; MPN SSM3J332R,LF
R1: 604 1%; R1005
R2: 100k; R1005
R3: 18k 1%; R1005
R4: 27k 1%; R1005
R5: 1k; R1005
TH1: NCP15XH103F03RC; MPN NCP15XH103F03RC
U1: BQ25172DSGR; Texas_DSG0008A_WSON-8-1EP_2x2mm_P0.5mm_EP0.9x1.6mm

Connections:
+BATT: C3.1, J2.1, Q1.3 (D), U1.8 (OUT)
/ISET: R1.1, U1.2 (ISET)
/STAT: LED1.1 (K), U1.5 (STAT)
/TMR: R4.1, U1.6 (TMR)
/TS: J3.1, TH1.1, U1.3 (TS)
/VOUT: C4.1, D1.1 (K), J1.3, Q1.2 (S)
/VSET: R3.1, U1.7 (VSET)
GND: C1.2, C2.2, C3.2, C4.2, J1.1, J2.2, J3.2, R1.2, R2.2, R3.2, R4.2, TH1.2, U1.4 (GND), U1.9 (TM)
unnamed: LED1.2 (A), R5.2
VBUS: C1.1, C2.1, D1.2 (A), J1.2, Q1.1 (G), R2.1, R5.1, U1.1 (IN)

Notes on the sheet:
入出力 / Input & Output
充電IC BQ25172 (NiMH 3セル, 500mA, 6h)
パススルー / Load sharing USBあり: VBUS→D1→VOUT, Q1 OFF USBなし: +BATT→Q1(ON)→VOUT
基板: 12x20mm, 片面実装, SBH-331AS(秋月102666)のスイッチ部の隙間に縦置き TH1 は基板に載せず J3 にリード線で接続し電池に貼付 / U1 EP にサーマルビア

Board: 2 copper layers, 20.0 x 12.0 mm, 16 parts (0 on the bottom side), 10 nets.

## KiCad design bsercon/bsercon.kicad_pcb

Board: 2 copper layers, 20.0 x 10.0 mm, 9 parts (4 on the bottom side), 8 nets.

Parts:
C1, C2, C3: 0u1; C1608
IC1: RT9080N-08GJ5; SOT94P280X100-5N
J1: Conn_01x04_Pin; 01x04
P1: USB_C_Plug; USB_C_3.0_PLUG
R1, R2: 4k7; R1005
U1: CH340K; SSOP-10-1EP_3.9x4.9mm_P1mm_EP2.1x3.3mm

Connections:
+3V3: C1.2, C3.2, IC1.5 (VOUT), J1.3, U1.7 (VCC), U1.10 (V3)
/D+: P1.A6 (D+), U1.1 (UD+)
/D-: P1.A7 (D-), U1.2 (UD-)
/UART: J1.1, U1.8 (TXD), U1.9 (RXD)
GND: C1.1, C2.1, C3.1, IC1.2 (GND), J1.2, P1.A1 (GND), P1.A12 (GND), P1.B1 (GND), P1.B12 (GND), P1.SH (SHIELD), R1.2, R2.2, U1.3 (GND), U1.11 (GND)
unnamed: P1.A5 (CC), R2.1
unnamed: P1.B5 (VCONN), R1.1
VBUS: C2.2, IC1.1 (VIN), IC1.3 (EN), J1.4, P1.A4 (VBUS), P1.A9 (VBUS), P1.B4 (VBUS), P1.B9 (VBUS)

## KiCad design tinyx04/tinyx04.kicad_pcb

Parts:
C1, C2: 0.1u; 1005
J1: Conn_01x04_Pin; pad05
J2, J3: Conn_01x06_Pin; pad06
J4: Conn_01x01_Pin; pad01_1x1_5
R1: 10k; R1005
R2, R3, R4: 4.7k; R1005
SW1: SW_MEC_5E; SKRPABE010
U1: TS5A23159DGS; TSSOP-10_3x3mm_P0.5mm
U2: ATtiny1604-SS; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
+3V3: C2.2, J1.4, R1.2, U1.8 (VCC), U2.1 (VCC)
/#RTS: J4.1 (Pin_1_1), U1.1, U1.5
/PA0: C1.2, J2.3, R1.1, SW1.3 (K), SW1.4 (A), U2.10 (~RESET/PA0)
/PA1: J2.4, U2.11 (PA1)
/PA2: J2.5, U2.12 (PA2)
/PA4: J3.1, U2.2 (PA4)
/PA5: J3.2, U2.3 (PA5)
/PA6: J3.3, U2.4 (PA6)
/PA7: J3.4, U2.5 (PA7)
/PB0: J2.2, U2.9 (PB0)
/PB1: J2.1, U2.8 (PB1)
/Rx: J1.2, U1.10
/Rx3: J3.5, R2.2, U2.6 (PB3)
/Tx: J1.1, U1.6
/Tx2: J3.6, R3.2, U2.7 (PB2)
/UPDI: J2.6, R4.2, U1.2, U2.13 (PA3)
GND: C1.1, C2.1, J1.3, SW1.1, SW1.2, U1.3 (GND), U2.14 (GND)
unnamed: R2.1, U1.9
unnamed: R3.1, U1.7
unnamed: R4.1, U1.4

Notes on the sheet:
INA181A2: 増幅率50倍 R=8mOhm, Vref: ATtiny内部基準電圧, V0=a*Vref, V1=b*Vrefとして I = (a-b)Vref/(50*R)

Board: 2 copper layers, 20.0 x 8.5 mm, 13 parts (10 on the bottom side), 20 nets.

## KiCad design ATtiny/ATtiny.kicad_pcb

Parts:
C1, C2: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D2: LED_Small; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J2: Conn_02x07_Counter_Clockwise; DIP-14_W10.16mm
R1, R2: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_MEC_5E; SW_SKRPABE010
U1: ATtiny1604-SS; SOIC-14_3.9x8.7mm_P1.27mm
U2: CH340K; SSOP-10-1EP_3.9x4.9mm_P1mm_EP2.1x3.3mm

Connections:
+5V: C1.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J2.1, U1.1 (VCC), U2.7 (VCC)
D+: J1.A6 (D+), J1.B6 (D+), U2.1 (UD+)
D-: J1.A7 (D-), J1.B7 (D-), U2.2 (UD-)
GND: C1.2, C2.2, D2.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.14, R1.2, R2.2, SW1.3 (K), SW1.4 (A), U1.14 (GND), U2.3 (GND), U2.11 (GND)
unnamed: D2.2 (A), R4.2
unnamed: J1.A5 (CC1), R1.1
unnamed: J1.B5 (CC2), R2.1
unnamed: C2.1, U2.10 (V3)
PA1: J2.11, U1.11 (PA1)
PA2: J2.12, U1.12 (PA2)
PA3: J2.13, U1.13 (PA3)
PA4: J2.2, U1.2 (PA4)
PA5: J2.3, U1.3 (PA5)
PA6: J2.4, U1.4 (PA6)
PA7: J2.5, SW1.1, SW1.2, U1.5 (PA7)
PB0: J2.9, U1.9 (PB0)
PB1: J2.8, U1.8 (PB1)
PB2: J2.7, U1.7 (PB2)
PB3: J2.6, U1.6 (PB3)
RTS#: R4.1, U2.6 (~RTS)
UPDI: J2.10, U1.10 (~RESET/PA0), U2.8 (TXD), U2.9 (RXD)

Board: 2 copper layers, 13.5 x 25.0 mm, 11 parts (5 on the bottom side), 21 nets.

## KiCad design ammeter3/ammeter2.kicad_pcb

Parts:
C1, C6, C8, C16: 0.1u; 1005
C3: 1n; 1005
C5: 10u; C_1206_3216Metric
C7, C9: 22u; C1608
C10, C11, C12: 1u; 1005
C13, C14: 4.7u; 1005
D1: D_Zener_Dual_CommonAnode_KKA_Parallel; SOT-323_SC-70
FB1: 470m; L_0603_1608Metric
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4110
L1: 4.7u; C2520
P1: USB_C_Plug; USB_C_3.0_PLUG
R1: 8m; R_0805_2012Metric
R2: 100; R1005
R4, R6, R11: 10k; R1005
R5: 100k; R1005
R7, R8, R9, R12: 4.7k; R1005
R10: 1k; R1005
S1: THAF01-NC-R; THAF01NCR; Manufacturer_Part_Number THAF01-NC-R
U2: TLV9001IDCK; SOT-353_SC-70-5
U3: INA181; SOT-23-6
U5: AP63203WU; TSOT-23-6
U6: X032-6032TSWAG02-H14 F
U8: ATtiny1604-SS; SOIC-14_3.9x8.7mm_P1.27mm
U10: MCP1501-12xCH; SOT-23-6

Connections:
+3V3: C1.1, C7.2, C9.2, C14.1, FB1.1, L1.2, R4.2, R6.2, R7.2, R8.2, U2.5 (V+), U3.6 (V+), U5.1 (FB), U6.5 (VBAT), U6.8 (Vdd), U10.4 (~SHDN), U10.6 (VDD)
/RES: R6.1, U6.9 (#RES), U8.11 (PA1)
/Rx3: R12.2, U8.6 (PB3)
/SCL: R7.1, U6.10 (SCL), U8.9 (PB0)
/SDA: R8.1, U6.11 (SDA), U8.8 (PB1)
/Tx2: R9.2, U8.7 (PB2)
/UPDI: P1.B8 (SBU2), U8.10 (~RESET/PA0)
/V0: U3.1, U8.2 (PA4)
/V1: R2.2, U8.3 (PA5)
/V2: R10.1, R11.1, U8.13 (PA3)
/cc: J1.A5 (CC1), P1.A5 (CC)
/ref: C5.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), R1.2, U3.3 (+), U5.2 (EN), U5.3 (IN)
/sw1: C8.2, R4.1, S1.3 (A1), S1.4 (A2), U8.12 (PA2)
GND: C1.2, C3.2, C5.2, C7.1, C8.1, C9.1, C12.2, C13.2, C14.2, C16.1, D1.3 (A), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.SH (SHIELD), P1.A1 (GND), P1.A12 (GND), P1.B1 (GND), P1.B12 (GND), P1.SH (SHIELD), R5.2, R10.2, S1.1 (B1), S1.2 (B2), U2.2 (V-), U3.2 (GND), U5.4 (GND), U6.7 (Vss), U8.14 (GND), U10.2 (GND), U10.3 (GND), U10.5 (GND), U10.[2,3,5] (GND)
unnamed: J1.B5 (CC2), P1.B5 (VCONN)
unnamed: D1.2 (K), J1.A6 (D+), J1.B6 (D+), P1.A6 (D+), R12.1
unnamed: D1.1 (K), J1.A7 (D-), J1.B7 (D-), P1.A7 (D-), R9.1
unnamed: C3.1, R2.1, U2.3 (-), U2.4, U3.5 (REF)
unnamed: C6.1, U5.6 (BST)
unnamed: C6.2, L1.1, U5.5 (SW)
unnamed: C11.2, U6.4 (C1N)
unnamed: C11.1, U6.3 (C1P)
unnamed: C10.2, U6.2 (C2N)
unnamed: C10.1, U6.1 (C2P)
unnamed: R5.1, U6.12 (IREF)
unnamed: C12.1, U6.13 (VCOMH)
unnamed: C13.1, U6.14 (Vcc)
unnamed: U2.1 (+), U10.1 (OUT)
VBUS: P1.A4 (VBUS), P1.A9 (VBUS), P1.B4 (VBUS), P1.B9 (VBUS), R1.1, R11.2, U3.4 (-)
VCC: C16.2, FB1.2, U8.1 (VCC)

Notes on the sheet:
INA181A2: 増幅率50倍 R=8mOhm, Vref: ATtiny内部基準電圧, V0=a*Vref, V1=b*Vrefとして I = (a-b)Vref/(50*R)

Board: 4 copper layers, 25.0 x 15.0 mm, 36 parts (21 on the bottom side), 30 nets.

## Commit log (part)

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2026-05-16 commit2605161301
2026-05-16 readme
2026-05-16 Fix formatting issues in README.
2026-05-17 2605171513
2026-05-18 2605181741
2026-05-28 2605281137
2026-05-28 2605281203
